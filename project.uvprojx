# Keil uVision project project.uvprojx, settings and files
target rtthread-frdm-mcxa156 (6220000::V6.22::ARMCLANG)
  device: MCXA156VLL NXP
  pack: NXP.MCXA156_DFP.25.06.00
  cpu: IRAM(0x20000000,0x01e000) IRAM2(0x04000000,0x3000) IROM(0x03000000,0x2000) IROM2(0x00000000,0x100000) CPUTYPE("Cortex-M33") FPU3(SFPU) DSP CLOCK(12000000) ELITTLE
  output: rtthread
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=3
  c define: __CLK_TCK=RT_TICK_PER_SECOND, __RTTHREAD__, __STDC_LIMIT_MACROS, CPU_MCXA156VLL, RT_USING_LIBC, RT_USING_ARMLIBC, CONFIG_USB_HS, DEBUG
  c misc: --target=arm-arm-none-eabi
  c include: ..\..\..\..\..\components\utilities\ulog;..\..\..\..\..\libcpu\arm\cortex-m33;..\..\..\..\..\components\libc\posix\io\eventfd;..\..\..\..\..\components\drivers\usb\cherryusb;..\..\..\..\..\components\drivers\include;..\..\..\..\..\components\drivers\phy;..\..\..\..\..\components\drivers\usb\cherryusb\class\cdc;..\..\..\..\..\components\drivers\include;..\..\..\..\..\components\drivers\usb\cherryusb\class\audio;..\..\..\..\..\components\drivers\include;..\..\..\..\..\components\drivers\usb\cherryusb\class\hid;board\MCUX_Config\board;..\Libraries\drivers\config;packages\nxp-mcx-series-latest\MCXA156\middleware\sdmmc\inc;..\..\..\..\..\components\libc\posix\io\epoll;board\ports;packages\nxp-mcx-series-latest\MCXA156\middleware\sdmmc\port;..\..\..\..\..\components\drivers\usb\cherryusb\core;..\Libraries\drivers;..\..\..\..\..\components\drivers\usb\cherryusb\osal;..\..\..\..\..\components\drivers\usb\cherryusb\class\vendor\net;applications;..\..\..\..\..\components\drivers\usb\cherryusb\class\wireless;..\..\..\..\..\components\drivers\include;..\..\..\..\..\include;..\..\..\..\..\components\drivers\usb\cherryusb\class\hub;..\..\..\..\..\components\libc\posix\ipc;packages\nxp-mcx-series-latest\MCXA156;..\..\..\..\..\components\drivers\usb\cherryusb\class\dfu;packages\nxp-mcx-series-latest\MCXA156\components\codec;..\..\..\..\..\components\drivers\usb\cherryusb\class\vendor\wifi;board\ports\cherryusb;board;..\..\..\..\..\components\libc\compilers\common\include;..\..\..\..\..\components\drivers\usb\cherryusb\class\video;..\..\..\..\..\libcpu\arm\common;packages\nxp-mcx-series-latest\MCXA156\drivers;..\..\..\..\..\components\libc\compilers\common\extension;..\..\..\..\..\components\libc\posix\io\poll;..\..\..\..\..\components\drivers\usb\cherryusb\class\adb;..\..\..\..\..\components\drivers\usb\cherryusb\class\midi;..\..\..\..\..\components\libc\compilers\common\extension\fcntl\octal;..\..\..\..\..\components\drivers\include;..\..\..\..\..\components\drivers\usb\cherryusb\class\vendor\serial;.;..\..\..\..\..\components\drivers\include;..\..\..\..\..\components\drivers\usb\cherryusb\class\msc;..\..\..\..\..\components\drivers\include;..\..\..\..\..\components\drivers\usb\cherryusb\common;..\..\..\..\..\components\finsh;..\..\..\..\..\components\drivers\smp_call;packages\nxp-mcx-cmsis-latest\Core\Include
  asm misc: -x assembler-with-cpp
  memory RVCT4: ROM 0x3000000 size 0x2000
  memory RVCT5: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x1e000
  memory RVCT10: RAM 0x4000000 size 0x3000
  scatter file: .\board\linker_scripts\MCXA156_flash.scf
  group Applications
    applications/: usb_app.c main.c gamepad_app.c key_app.c joystick_app.c
  group CherryUSB
    ../../../../../components/drivers/usb/cherryusb/port/kinetis/: usb_dc_kinetis.c usb_glue_mcx.c
    ../../../../../components/drivers/usb/cherryusb/class/hid/: usbd_hid.c
    ../../../../../components/drivers/usb/cherryusb/platform/rtthread/: usb_msh.c usb_check.c
    ../../../../../components/drivers/usb/cherryusb/osal/: usb_osal_rtthread.c
    ../../../../../components/drivers/usb/cherryusb/core/: usbd_core.c
  group cherryusb-port
    board/ports/cherryusb/: cherryusb.c
  group Compiler
    ../../../../../components/libc/compilers/armlibc/: syscall_mem.c syscalls.c
    ../../../../../components/libc/compilers/common/: cctype.c cstdlib.c cstring.c ctime.c cunistd.c cwchar.c
  group DeviceDrivers
    ../../../../../components/drivers/core/: device.c
    ../../../../../components/drivers/hwtimer/: hwtimer.c
    ../../../../../components/drivers/ipc/: completion_comm.c completion_up.c condvar.c dataqueue.c pipe.c ringblk_buf.c ringbuffer.c waitqueue.c workqueue.c
    ../../../../../components/drivers/misc/: adc.c
    ../../../../../components/drivers/pin/: dev_pin.c
    ../../../../../components/drivers/serial/: dev_serial.c
  group Drivers
    board/MCUX_Config/board/: clock_config.c pin_mux.c
    board/: board.c
    board/ports/: drv_spi_sample_rw007.c
    ../Libraries/drivers/: drv_adc.c drv_pin.c drv_uart.c
  group Finsh
    ../../../../../components/finsh/: cmd.c msh.c shell.c msh_parse.c
  group Kernel
    ../../../../../src/: clock.c components.c cpu_up.c defunct.c idle.c ipc.c irq.c kservice.c mem.c mempool.c object.c scheduler_comm.c scheduler_up.c thread.c timer.c
  group klibc
    ../../../../../src/klibc/: kerrno.c rt_vsscanf.c kstring.c kstdio.c rt_vsnprintf_std.c
  group libcpu
    ../../../../../libcpu/arm/common/: atomic_arm.c div0.c showmem.c
    ../../../../../libcpu/arm/cortex-m33/: context_rvds.S cpuport.c syscall_rvds.S trustzone.c
  group Libraries
    packages/nxp-mcx-series-latest/MCXA156/arm/: startup_MCXA156.s
    packages/nxp-mcx-series-latest/MCXA156/drivers/: fsl_aoi.c fsl_clock.c fsl_cmc.c fsl_common.c fsl_common_arm.c fsl_crc.c fsl_ctimer.c fsl_edma.c fsl_edma_soc.c fsl_eim.c fsl_eqdc.c fsl_erm.c fsl_freqme.c fsl_glikey.c fsl_gpio.c fsl_i3c.c fsl_i3c_edma.c fsl_inputmux.c fsl_lpadc.c fsl_lpcmp.c fsl_lpi2c.c fsl_lpi2c_edma.c fsl_lpspi.c fsl_lpspi_edma.c fsl_lptmr.c fsl_lpuart.c fsl_lpuart_edma.c fsl_ostimer.c fsl_pwm.c fsl_reset.c fsl_spc.c fsl_utick.c fsl_vbat.c fsl_waketimer.c fsl_wuu.c fsl_wwdt.c
    packages/nxp-mcx-series-latest/MCXA156/: system_MCXA156.c
  group Utilities
    ../../../../../components/utilities/ulog/: ulog.c
    ../../../../../components/utilities/ulog/backend/: console_be.c
